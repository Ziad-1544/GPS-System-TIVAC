# Keil uVision project V1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: V1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s BIT_MATH.h CLCD_config.h CLCD_interface.h CLCD_private.h CLCD_program.c GPIO_config.h GPIO_Interface.h GPIO_private.h GPIO_program.c LED_config.h LED_interface.h LED_private.h LED_program.c main.c STD_TYPES.h SW_config.h SW_interface.h SW_private.h SW_program.c system_TM4C123.c SYSTICK_config.h SYSTICK_interface.h SYSTICK_private.h SYSTICK_program.c
